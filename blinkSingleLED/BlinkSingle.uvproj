# Keil uVision project BlinkSingle.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C2051 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: Blink1.2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: blink1.2.asm
